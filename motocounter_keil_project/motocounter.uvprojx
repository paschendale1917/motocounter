# Keil uVision project motocounter.uvprojx, settings and files
target user (6190000::V6.19::ARMCLANG)
  device: STM32G030F6Px STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.5.0
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: motocounter_g030_improved +hex
  c flags: Optim=7 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=1 wLevel=4
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group RCC
    ./user_drivers/RCC/: RCC.c RCC.h
  group SysTick
    ./user_drivers/SysTick/: systick_delay.h systick_delay.c
  group main
    ./: main.h main.c
  group spi
    ./user_drivers/spi/: spi.h spi.c
  group st7735
    ./user_drivers/st7735/: ArialNumFontPlus.c BigFont.c DotMatrix_L_Num.c DotMatrix_M_Slash.c DotMatrix_XL_Num.c fonts.h Grotesk16x32.c Grotesk24x48.c GroteskBold16x32_DK_NO.c TinyFont.c st7735.c st7735.h mipt.c motofan.c
  group st7735_backlight
    ./user_drivers/st7735_backlight/: backlight.c backlight.h
  group menu
    ./user_drivers/menu/: menu.h menu.c
  group handlers
    ./user_drivers/menu/: handlers.c handlers.h
  group buttons
    ./user_drivers/buttons/: buttons.c buttons.h
  group buzzer
    ./user_drivers/buzzer/: buzzer.c buzzer.h
  group timer
    ./user_drivers/timer/: timer.c timer.h
  group ADC
    ./user_drivers/ADC/: ADC.h ADC.c
  group i2c
    ./user_drivers/i2c/: i2c.h i2c.c
  group eeprom
    ./user_drivers/eeprom/: eeprom.h eeprom.c
  group ws2812
    ./user_drivers/ws2812/: ws2812_dma.c ws2812_dma.h
  group WWDG
    ./user_drivers/wwdg/: WWDG.c WWDG.h
  group standby_led
    ./user_drivers/standby_led/: standby_led.c standby_led.h
software components: CMSIS:CORE 6.1.1, Device:Startup 1.4.2
